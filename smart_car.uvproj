# Keil uVision project smart_car.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: smart_car +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    D:/test2.c/smart_car/smart_car2/smart_car/: BEEP.c DIGITAL.c DOT_MATRIX.c KEY_INTERRUPT.c LED.c main.c MOTOR.c
